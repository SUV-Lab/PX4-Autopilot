## src/modules/monitoring/Kconfig
```kconfig
menuconfig MODULES_MONITORING
	bool "monitoring"
	default n
	---help---
		Enable support for the monitoring
```
